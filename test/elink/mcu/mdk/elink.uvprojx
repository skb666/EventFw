# Keil uVision project elink.uvprojx, settings and files
target elink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eventos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx, EOS_MCU, USE_STDPERIPH_DRIVER,
  c include: ..\APP;..\f429;..\f429\inc;..\..\..\..\eventos;..\..\..\..\service\elink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c hook.c
  group f429
    ../f429/: system_stm32f4xx.c startup_stm32f429_439xx.s
    ../f429/src/: stm32f4xx_tim.c stm32f4xx_rcc.c misc.c
  group OS
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../eventos/: eos.c eos_kernel.c
  group elink
    ../../../../service/elink/: elink_mcu.c
