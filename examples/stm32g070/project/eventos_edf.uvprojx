# Keil uVision project eventos_edf.uvprojx, settings and files
target eventos_edf (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: eventos_edf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ..\..\..\eventos;..\mcu\stm32g070\CMSIS;..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\mcu\stm32g070\STM32G070;..\user;..\user\app;..\user\bsp;..\user\config;..\..\..\common;..\..\..\elib;..\..\..\common\log\inc;.;..\..\..\edf\devf;..\..\..\edf\dev\serial;..\..\..\3rd\Shell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group startup
    ../mcu/stm32g070/STM32G070/arm/: startup_stm32g070xx.s
  group HAL
    ../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_i2s.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_wwdg.c
  group eventos
    ../../../eventos/: eventos.c
  group user.app
    ../user/app/: eos_led_reactor.c eos_led_sm.c main.c port_stm32g070.c eos_shell.c
  group user.bsp
    ../user/bsp/: bsp.c elab_time.c stm32g0xx_it.c system_stm32g0xx.c
    ../user/driver/: drv_uart.c
  group common
    ../../../common/: elab_assert.c elab_common.c elab_export.c
    ../../../common/log/src/: elab_log.c elab_log_port.c
  group elib
    ../../../elib/: elib_crc.c elib_queue.c hash_table.c
  group edf.framework
    ../../../edf/devf/: devf.c
  group edf.device
    ../../../edf/dev/serial/: elab_serial.c
  group 3rd.shell
    ../../../3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
