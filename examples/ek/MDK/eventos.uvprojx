# Keil uVision project eventos.uvprojx, settings and files
target EventOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eventos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx, EOS_MCU, USE_STDPERIPH_DRIVER,
  c include: ..\APP;..\MCU;..\..\..\eventos;..\..\..\test;..\MCU\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c hook.c bsp.c
  group MCU
    ../MCU/: system_stm32f4xx.c startup_stm32f429_439xx.s
    ../MCU/src/: stm32f4xx_tim.c stm32f4xx_rcc.c misc.c
  group EventOS
    ../../../eventos/: eventos.c eos_kernel.c
    ../../../eos_port/: port_cortex_m.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Test
    ../../../test/: eos_led_reactor.c eos_led_sm.c test_01_0.c test_01_1.c test_05_0.c test_05_1.c test_02_0.c test_02_1.c test_02_2.c test_03.c test_04.c test_06.c test_07.c test_08.c test_09.c test_11.c test_10.c
